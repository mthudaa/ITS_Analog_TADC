v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/ipin.sym} 180 -580 0 0 {name=p18 lab=VDD}
C {devices/ipin.sym} 180 -560 0 0 {name=p19 lab=CF[0:8]}
C {devices/ipin.sym} 180 -540 0 0 {name=p20 lab=SW_IN[0:8]}
C {devices/ipin.sym} 180 -520 0 0 {name=p22 lab=VCM}
C {devices/ipin.sym} 180 -500 0 0 {name=p23 lab=VSS}
C {devices/iopin.sym} 160 -470 0 0 {name=p24 lab=S[0:8]}
C {cdac_sw_3.sym} 600 -530 0 0 {name=x1[0:8]}
C {devices/lab_wire.sym} 450 -570 0 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 450 -490 0 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 750 -570 2 0 {name=p67 sig_type=std_logic lab=S[0:8]}
C {devices/lab_wire.sym} 450 -510 0 0 {name=p70 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 450 -550 0 0 {name=p71 sig_type=std_logic lab=CF[0:8]}
C {devices/lab_wire.sym} 450 -530 0 0 {name=p73 sig_type=std_logic lab=SW_IN[0:8]}
C {devices/code_shown.sym} 410 -420 0 0 {name=s1 only_toplevel=false value=".include /usr/local/share/pdk/sky130A/libs.ref/sky130_fd_sc_hs/spice/sky130_fd_sc_hs.spice"}
