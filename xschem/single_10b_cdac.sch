v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/lab_wire.sym} 660 -90 0 1 {name=p9 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 660 -110 0 1 {name=p16 sig_type=std_logic lab=VC}
C {devices/ipin.sym} 160 -240 0 0 {name=p18 lab=VDD}
C {devices/ipin.sym} 160 -220 0 0 {name=p19 lab=CF[0:7]}
C {devices/ipin.sym} 160 -200 0 0 {name=p20 lab=SW[0:7]}
C {devices/ipin.sym} 160 -180 0 0 {name=p22 lab=VCM}
C {devices/ipin.sym} 160 -160 0 0 {name=p23 lab=VSS}
C {devices/iopin.sym} 140 -130 0 0 {name=p24 lab=VC}
C {cdac_sw_10b.sym} 510 -210 0 0 {name=x1}
C {devices/lab_wire.sym} 360 -250 0 0 {name=p2 lab=VDD}
C {devices/lab_wire.sym} 360 -230 0 0 {name=p3 lab=CF[0:7]}
C {devices/lab_wire.sym} 360 -210 0 0 {name=p4 lab=SW[0:7]}
C {devices/lab_wire.sym} 360 -190 0 0 {name=p5 lab=VCM}
C {devices/lab_wire.sym} 360 -170 0 0 {name=p6 lab=VSS}
C {cap_array_10b.sym} 510 -100 0 0 {name=x2}
C {lab_wire.sym} 660 -250 0 1 {name=p1 lab=S[0:7]}
C {lab_wire.sym} 360 -110 0 0 {name=p7 lab=S[0:7]}
