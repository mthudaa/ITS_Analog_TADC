v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
C {devices/ipin.sym} 180 -580 0 0 {name=p18 lab=VDD}
C {devices/ipin.sym} 180 -560 0 0 {name=p19 lab=CF[0:7]}
C {devices/ipin.sym} 180 -540 0 0 {name=p20 lab=SW_IN[0:7]}
C {devices/ipin.sym} 180 -520 0 0 {name=p22 lab=VCM}
C {devices/ipin.sym} 180 -500 0 0 {name=p23 lab=VSS}
C {devices/iopin.sym} 160 -470 0 0 {name=p24 lab=S[0:7]}
C {cdac_sw_1.sym} 570 -550 0 0 {name=x1[0:1]}
C {devices/lab_wire.sym} 420 -590 0 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 420 -510 0 0 {name=p65 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 720 -590 2 0 {name=p67 sig_type=std_logic lab=S[0:1]}
C {devices/lab_wire.sym} 420 -530 0 0 {name=p70 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 420 -570 0 0 {name=p71 sig_type=std_logic lab=CF[0:1]}
C {devices/lab_wire.sym} 420 -550 0 0 {name=p73 sig_type=std_logic lab=SW_IN[0:1]}
C {cdac_sw_3.sym} 1010 -550 0 0 {name=x3[0:1]}
C {devices/lab_wire.sym} 860 -590 0 0 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 860 -510 0 0 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1160 -590 2 0 {name=p4 sig_type=std_logic lab=S[4:5]}
C {devices/lab_wire.sym} 860 -530 0 0 {name=p5 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 860 -570 0 0 {name=p6 sig_type=std_logic lab=CF[4:5]}
C {devices/lab_wire.sym} 860 -550 0 0 {name=p7 sig_type=std_logic lab=SW_IN[4:5]}
C {cdac_sw_2.sym} 570 -410 0 0 {name=x7[0:1]}
C {devices/lab_wire.sym} 420 -450 0 0 {name=p34 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 420 -370 0 0 {name=p35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 720 -450 2 0 {name=p36 sig_type=std_logic lab=S[2:3]}
C {devices/lab_wire.sym} 420 -390 0 0 {name=p37 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 420 -430 0 0 {name=p38 sig_type=std_logic lab=CF[2:3]}
C {devices/lab_wire.sym} 420 -410 0 0 {name=p39 sig_type=std_logic lab=SW_IN[2:3]}
C {cdac_sw_4.sym} 1010 -410 0 0 {name=x8[0:1]}
C {devices/lab_wire.sym} 860 -450 0 0 {name=p40 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 860 -370 0 0 {name=p41 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1160 -450 2 0 {name=p42 sig_type=std_logic lab=S[6:7]}
C {devices/lab_wire.sym} 860 -390 0 0 {name=p43 sig_type=std_logic lab=VCM}
C {devices/lab_wire.sym} 860 -430 0 0 {name=p44 sig_type=std_logic lab=CF[6:7]}
C {devices/lab_wire.sym} 860 -410 0 0 {name=p45 sig_type=std_logic lab=SW_IN[6:7]}
